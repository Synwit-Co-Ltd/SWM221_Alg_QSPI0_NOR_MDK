# Keil uVision project SWM221_StdPeriph_Driver.uvprojx, settings and files
target 3BYTE_ADDR (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM221xB Synwit
  pack: Synwit.SWM32_DFP.2.2.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SWM221_QSPI0_NOR +hex
  AfterMake: cmd.exe /C copy "out\%L" "out\@L.FLM"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=1
  c define: CHIP_SWM221
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM221_StdPeriph_Driver
  asm define: CHIP_SWM221
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\APP\linker.sct
  link misc: --diag_suppress L6305
  group APP
    ./APP/: FlashDev.c FlashPrg.c
  group CSL\StdPD
    ./CSL/SWM221_StdPeriph_Driver/: SWM221_port.c SWM221_gpio.c SWM221_qspi.c SWM221_flash.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM221.c
